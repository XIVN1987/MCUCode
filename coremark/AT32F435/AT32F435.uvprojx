# Keil uVision project AT32F435.uvprojx, settings and files
target AT32F435 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F435VGT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.1.1
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: coremark +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf --text -a -c -o "$L@L.asm" "#L"
  c flags: Optim=4 oTime=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F435VG,USE_STDPERIPH_DRIVER, HEXT_VALUE=12000000, ITERATIONS=12000
  c include: ..\..\board_STM32\AT32F435\src\CSL\AT32F43x_StdPeriph_Driver;..\..\board_STM32\AT32F435\src\CSL\CMSIS\DeviceSupport;..\..\board_STM32\AT32F435\src\CSL\CMSIS\CoreSupport;..\..\board_STM32\AT32F435\src\CSL;.\src;..\coremark
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group APP
    ./src/: hw_port.c core_portme.c
  group coremark
    ../coremark/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c
  group CSL/CMSIS
    ../../board_STM32/AT32F435/src/CSL/CMSIS/DeviceSupport/: system_at32f435_437.c
    ../../board_STM32/AT32F435/src/CSL/CMSIS/DeviceSupport/startup/mdk/: startup_at32f435_437.s
  group CSL/StdPD
    ../../board_STM32/AT32F435/src/CSL/AT32F43x_StdPeriph_Driver/: at32f435_437_acc.c at32f435_437_adc.c at32f435_437_can.c at32f435_437_crc.c at32f435_437_crm.c at32f435_437_dac.c at32f435_437_debug.c at32f435_437_dma.c at32f435_437_dvp.c at32f435_437_edma.c at32f435_437_emac.c at32f435_437_ertc.c at32f435_437_exint.c at32f435_437_flash.c at32f435_437_gpio.c at32f435_437_i2c.c at32f435_437_misc.c at32f435_437_pwc.c at32f435_437_qspi.c at32f435_437_scfg.c at32f435_437_sdio.c at32f435_437_spi.c at32f435_437_tmr.c at32f435_437_usart.c at32f435_437_usb.c at32f435_437_wdt.c at32f435_437_wwdt.c at32f435_437_xmc.c
