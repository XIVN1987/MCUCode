# Keil uVision project STM32F103.uvprojx, settings and files
target STM32F103 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: coremark +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf --text -a -c -o "$L@L.asm" "#L"
  c flags: Optim=3 oTime=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD USE_STDPERIPH_DRIVER ITERATIONS=2000
  c include: ..\..\board_STM32\STM32F103\src\CSL;..\..\board_STM32\STM32F103\src\CSL\CMSIS\CoreSupport;..\..\board_STM32\STM32F103\src\CSL\CMSIS\DeviceSupport;..\..\board_STM32\STM32F103\src\CSL\STM32F10x_StdPeriph_Driver;.\src;..\coremark
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ./src/: hw_port.c core_portme.c
  group coremark
    ../coremark/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c
  group CSL/CMSIS
    ../../board_STM32/STM32F103/src/CSL/CMSIS/DeviceSupport/: system_stm32f10x.c
    ../../board_STM32/STM32F103/src/CSL/CMSIS/DeviceSupport/startup/arm/: startup_stm32f10x_md.s
  group CSL/StdPD
    ../../board_STM32/STM32F103/src/CSL/STM32F10x_StdPeriph_Driver/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
