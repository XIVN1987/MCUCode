# Keil uVision project Segger_RTT.uvprojx, settings and files
target STM32F405 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Segger_RTT +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf --text -a -c -o "$L@L.asm" "#L"
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx HSE_VALUE=12000000 USE_STDPERIPH_DRIVER
  c include: ..\STM32F405\src\CSL;..\STM32F405\src\CSL\CMSIS\CoreSupport;..\STM32F405\src\CSL\CMSIS\DeviceSupport;..\STM32F405\src\CSL\STM32F4xx_StdPeriph_Driver;.\src;.\src\RTT
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM4
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ./src/: main.c
  group RTT
    ./src/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group CSL/CMSIS
    ../STM32F405/src/CSL/CMSIS/DeviceSupport/: system_stm32f4xx.c
    ../STM32F405/src/CSL/CMSIS/DeviceSupport/startup/arm/: startup_stm32f40_41xxx.s
  group CSL/StdPD
    ../STM32F405/src/CSL/STM32F4xx_StdPeriph_Driver/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
